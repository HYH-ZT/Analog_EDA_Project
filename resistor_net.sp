* Simple Resistor Network
* 简单电阻网络测试电路

* 电源定义
VDD 102 0 DC 5

* 电阻网络
R1 102 103 100
R2 103 104 200
R3 104 105 150
R4 105 0 300

* 分析类型（根据需要选择）
.dc
